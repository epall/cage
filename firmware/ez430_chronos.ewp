# IAR project ez430_chronos.ewp, settings and files
configuration Debug - 868MHz - Full (Uses 868MHz ISM band, requires full IAR license) (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 256
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ISM_EU
  ICC430.newCCIncludePaths: ; include\; driver\; logic\; bluerobin\; simpliciti\; bluerobin\code; bluerobin\lib; bluerobin\lib\br_rx
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
  XLINK.XlinkStackSize: 1
configuration Debug - 868MHz - Limited (Uses 868MHz ISM band, works with limited compiler license) (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptStrategy: 0
  XLINK.XExtraOptions: --ks_version
configuration Debug - 915MHz - Limited (Uses 915MHz ISM band, works with limited compiler license) (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 80
  ICC430.CCDefines: ISM_US
  ICC430.newCCIncludePaths: ; include\; driver\; logic\; bluerobin\; simpliciti\
  ICC430.CCOptStrategy: 0
  XLINK.XExtraOptions: --ks_version
configuration Debug - 915MHz - Full (Uses 915MHz ISM band, requires full IAR license) (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 80
  ICC430.CCDefines: ISM_US
  ICC430.newCCIncludePaths: as above
  ICC430.CCOptStrategy: 0
  group (top)
    ./: main.c
  group driver
    driver/: adc12.c adc12.h buzzer.c buzzer.h display.c display.h display1.c ez430_chronos_codesize_limited_drivers.r43 pmm.c pmm.h ports.c ports.h radio.c radio.h rf1a.c rf1a.h timer.c timer.h vti_as.c vti_as.h vti_ps.c vti_ps.h
  group include
    include/: project.h
  group logic
    logic/: acceleration.c acceleration.h alarm.c alarm.h altitude.c altitude.h battery.c battery.h bluerobin_stubs.c cage.c clock.c clock.h date.c date.h menu.c menu.h rfsimpliciti.c rfsimpliciti.h stopwatch.c stopwatch.h temperature.c temperature.h user.c user.h
  group simpliciti
    simpliciti/: cc430 end device ISM_EU.r43 cc430 end device ISM_US.r43 simpliciti.h
